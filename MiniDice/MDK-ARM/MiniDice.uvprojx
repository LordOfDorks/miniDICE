# Keil uVision project MiniDice.uvprojx, settings and files
target MiniDice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L082KZ STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: MiniDice +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L082xx
  c misc: --C99
  c include: ../Inc;../../Dice/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000200 size 0x4e00
  scatter file: MiniDice.sct
  link misc: --diag_suppress=L6329
--diag_suppress=L6314
  group Application/MDK-ARM
    ./: startup_stm32l082xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pcd.c stm32l0xx_hal_uart.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_firewall.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: stm32l0xx_it.c usbd_desc.c usbd_conf.c usb_device.c usbd_dfu_if.c stm32l0xx_hal_msp.c main.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Application/Dice
    ../../Dice/Src/: DiceCore.c DiceData.c DiceEcc.c DiceHmac.c DiceKdf.c DiceSha256.c DiceHelper.c
software components: CMSIS:CORE 4.1.0
